# Keil uVision project STM32F429I.uvprojx, settings and files
target STM32F429I Configuration (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F439ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MQ-135 Gas Sensor +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F439xx
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Include;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c gpio.c main.c stm32f4xx_it.c dma.c adc.c usart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f439xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_adc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c
software components: CMSIS:CORE 5.6.0
